Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Selected elements only], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Element Parameters: Off], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off]
File name: D:\20210414 DW Windsor Quotation\IFC\IFC\Kirium Pro Midi PT76.ifc
Time: 2021-05-07T09:24:37
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 20.0.0 INT FULL Windows version (IFC2x3 add-on version: 3012 INT FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 24, 28, 0, 0; RefLongitude: 54, 25, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Ground Floor
In: Building
Elevation: 0 mm

# IfcFurnishingElement: Kirium Pro Midi PT76, FU - 002
In: Ground Floor
Material: Background
Pset_ManufacturerOccurrence - BarCode: Undefined; SerialNumber: Undefined
Pset_ManufacturerTypeInformation - ModelLabel: Undefined; Manufacturer: Undefined; ProductionYear: DD/MM/YYYY
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
